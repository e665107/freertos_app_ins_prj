# IAR project f429_freeos_test.ewp, settings and files
configuration f429_freeos_test (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429IG ST STM32F429IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ../main/inc; ../soclib/STM32F4xx_HAL_Driver/Inc; ../soclib/STM32F4xx_HAL_Driver/Inc/Legacy; ../middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../soclib/CMSIS/Device/ST/STM32F4xx/Include; ../middlewares/Third_Party/FreeRTOS/Source/include; ../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../soclib/CMSIS/Include; ../app/led; ../bsp/inc; ../lib; ../app/coding_frame; ../app/coding_frame/function/hsm; ../middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../main/inc
  OBJCOPY.OOCOutputFile: f429_freeos_test.srec
  ILINK.IlinkOutputFile: template_project.out
  ILINK.IlinkIcfFile: G:\test_projects\stm32f429_freertos_test_iar\main\src\stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../app/coding_frame/: coding_frame_creat.c uart_485_process.c
  group bsp
    ../bsp/src/: bsp_ll_uart.c bsp_pcf8574.c bsp_rs485.c bsp_soft_i2c.c
  group freertos
    ../middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group lib
    ../lib/: common.c delay.c
  group main
    ../main/src/: app_init.c bsp_init.c main.c soc_init.c startup_stm32f429xx.s stm32f4xx_hal_msp.c stm32f4xx_it.c system_run.c system_stm32f4xx.c
    ../middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group soclib
    ../soclib/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_ll_rcc.c stm32f4xx_ll_usart.c
