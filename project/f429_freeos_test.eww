<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\f429_freeos_test.ewp</path>
    </project>
    <batchBuild />
</workspace>
